## boards/shields/middle_earth_nice_view/Kconfig.shield
```kconfig
config SHIELD_NICE_VIEW_SHIELD_BASE
    def_bool $(shields_list_contains,middle_earth_nice_view)
```
